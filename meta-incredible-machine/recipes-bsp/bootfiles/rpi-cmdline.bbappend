CMDLINE:append = " systemd.run=/usr/lib/firstboot systemd.run_success_action=reboot systemd.run_failure_action=none systemd.unit=kernel-command-line.target"
