# We want ${DISTRO_CODENAME} in /etc/os-release...
VERSION_CODENAME = "${DISTRO_CODENAME}"
OS_RELEASE_FIELDS += "VERSION_CODENAME"
